# Keil uVision project shopkeeper.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: shopkeeper
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group ADC_DAC
    ./template/template/ADC_DAC/: adc_dac.h IRQ_adc.c lib_adc_dac.c
  group button
    ./template/template/button/: button.h IRQ_button.c lib_button.c
  group led
    ./template/template/led/: lib_led.c led.h
  group timer
    ./template/template/timer/: IRQ_timer.c lib_timer.c timer.h
  group template
    ./template/template/: sample.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
